EXTERNALSRC = "${TOPDIR}/../meta-sa/recipes-qt/lib-qt/sa-qml-components/files"
EXTERNALSRC_BUILD = "${WORKDIR}/externalsrc-build"

