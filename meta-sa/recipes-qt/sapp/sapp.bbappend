EXTERNALSRC = "${TOPDIR}/../meta-sa/recipes-qt/sapp/files"
EXTERNALSRC_BUILD = "${WORKDIR}/externalsrc-build"