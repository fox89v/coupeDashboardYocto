EXTERNALSRC = "${TOPDIR}/../meta-sa/recipes-qt/app-qt/files"
EXTERNALSRC_BUILD = "${WORKDIR}/externalsrc-build"