PACKAGECONFIG:append = " quick tools"
# PACKAGECONFIG:append:class-native = " tools"
# PACKAGECONFIG:append:class-nativesdk = " tools"
