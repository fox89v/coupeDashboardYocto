# Disabilita completamente QtPdf
PACKAGECONFIG = ""