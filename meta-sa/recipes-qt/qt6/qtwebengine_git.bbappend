LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

SRC_URI = ""
S = "${WORKDIR}"

do_fetch() {
    :
}

do_unpack() {
    :
}

do_configure() {
    :
}

do_compile() {
    :
}

do_install() {
    :
}
