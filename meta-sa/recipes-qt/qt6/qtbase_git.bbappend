PACKAGECONFIG:remove = "icu sql openssl x11 wayland widgets svg dbus tests"
