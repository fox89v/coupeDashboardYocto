# per l’SDK non ci servono i tool CLI (ocsptool, certtool, ecc.)
EXTRA_OECONF:class-nativesdk:append = " --disable-tools"
